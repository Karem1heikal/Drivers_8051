# Keil uVision project ADC_0808INTER.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ADC_0808INTER +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./LIB/: STD_TYPES.h BIT_MATH.h
    ./ADC/: ADC_config.h ADC_interface.h ADC_private.h ADC_program.c
    ./: main.c
    ./LCD/: LCD_config.h LCD_interface.h LCD_private.h LCD_program.c
